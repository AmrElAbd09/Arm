# Keil uVision project Project.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gpt2
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ./: App.c
  group HAL
    ./: Button.c Led.c motor.c Pwm.c Service.c
  group MCAL
    ./: Dio.c Dio_Lcfg.c Gpt.c Gpt_Lcfg.c Port.c Port_Lcfg.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
