# Keil uVision project TEST2.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TEST2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: App.c App.h Button.c Button.h Dio.c Dio.h Dio_Cfg.h Dio_Lcfg.c Dio_regs.h Dio_Types.h Led.c Led.h Macros.h Port.c Port.h Port_Cfg.h Port_Lcfg.c Port_regs.h Port_Types.h Std_Types.h Mcu_Hw.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.1
